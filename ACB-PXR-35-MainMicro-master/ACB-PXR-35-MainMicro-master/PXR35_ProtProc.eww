<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PXR35_ProtProc.ewp</path>
    </project>
    <batchBuild />
</workspace>
