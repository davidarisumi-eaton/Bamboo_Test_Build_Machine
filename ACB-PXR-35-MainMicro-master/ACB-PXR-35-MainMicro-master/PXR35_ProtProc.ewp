# IAR project PXR35_ProtProc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: Code; ACB-PXR-35-SensorBus_Common_All; Code\CAN
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PXR35_ProtProc.hex
  ILINK.IlinkOutputFile: PXR35_ProtProc.out
  ILINK.IlinkIcfFile: Code\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Code/: CAMCom.c Demand.c Diag.c DispComm.c Events.c Init.c Intr.c Iod.c main.c Meter.c Modbus.c Ovrcom.c Prot.c RealTime.c Setpnt.c startup_stm32f407xx.s Test.c
  group CAN_Comms
    Code/CAN/: can_driver.c can_tasks.c
  group CAN_Comms/pxcan
    ACB-PXR-35-SensorBus_Common_All/: can_setpoints.c pxcan.c
